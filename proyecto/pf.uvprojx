# Keil uVision project pf.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../: Buffer.c Buffer.h Delay.c Delay.h DOOM.c DOOM.h LPC1768_func.c LPC1768_func.h main.c SPI_LCD.c SPI_LCD.h structure.c structure.h entity.c entity.h sprites.h
software components: CMSIS:CORE 6.1.0, CMSIS Driver:SPI:SSP 2.7.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
